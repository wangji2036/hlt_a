# Keil uVision project mobile_power.uvprojx, settings and files
target Target 1 (6230000::V6.23::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: mobile_power +hex
  AfterMake: .\processing_firmware.bat @L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,SYSCLK_FREQ_HSI48
  c include: ..\Utilities\Common;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\WB\WB7720;..\Libraries\WB7720_StdPeriph_Driver\inc;..\Libraries\WB7720_USBDevice_Driver\inc;..\Projects
  memory RVCT4: ROM 0x8000200 size 0x7800
  memory RVCT9: RAM 0x200000c0 size 0xf40
  group User
    ./: config.h main.c usbd_hid.c usbd_user.c usbd_user_desc.c usbd_user_hid.c tw25071_display.c
    ../Utilities/Common/: bsp_uart0.c Retarget_uart0.c
  group CMSIS
    ../Libraries/CMSIS/Device/WB/WB7720/startup/arm/: startup_wb7720.s
    ../Libraries/CMSIS/Device/WB/WB7720/: system_wb7720.c
  group System
    ../Utilities/System/: system.lib
  group StdPeriph_Driver
    ../Libraries/WB7720_StdPeriph_Driver/src/: wb7720_gpio.c wb7720_rcc.c wb7720_i2c.c wb7720_exti.c wb7720_flash.c wb7720_misc.c wb7720_syscfg.c
  group USBDevice_Driver
    ../Libraries/WB7720_USBDevice_Driver/src/: usbd_hw.c usbd_intr.c usbd_core.c
